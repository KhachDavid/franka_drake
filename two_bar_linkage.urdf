Commit message: Update manual g comp in two bar linkage, showing perfect g comp

File: two_bar_linkage.urdf (robot description, URDF)
Before this commit: robot two_bar_linkage, 2 links, 2 joints
Joints:
- joint base_joint: origin xyz=0 0 0 rpy=0 0 0 -> xyz=0 0 0 rpy=0 -1.5708 0
